# Keil uVision project SignalR_Embedded_Client.uvprojx, settings and files
target Signalr Flash (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: LPC1768 NXP (founded by Philips)
  pack: Keil.LPC1700_DFP.2.4.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SignalR_Embbeded_Client +hex
  c flags: Optim=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: DEBUG_PRINTF
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x20007c00 size 0x8000
  scatter file: .\bin\Flash\CataMoeda.sct
  link misc: --show_parent_lib --show_full_path
  group src
    ./: main.c EMAC.c EMAC.h jsmn.c jsmn.h
  group doc
    ./: Abstract.txt
software components: CMSIS:CORE 5.1.2, CMSIS:RTOS:Keil RTX 4.81.1, Compiler:I/O:STDOUT 1.2.0, Network:CORE 7.9.0, Network:Interface:ETH 7.9.0, Network:Socket:TCP 7.9.0, Network:Socket:UDP 7.9.0, CMSIS Driver:Ethernet MAC 2.10.0, CMSIS Driver:Ethernet PHY:DP83848C 6.2.0, Device:GPDMA 1.2.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
